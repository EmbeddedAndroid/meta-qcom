# Same source revision as audioreach-kernel.
SRCREV = "6b1abf0c7fb0b8931575f4ef1d1f0926cdc5714f"
